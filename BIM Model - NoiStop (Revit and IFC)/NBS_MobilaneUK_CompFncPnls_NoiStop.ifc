Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-01-26T15:45:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Jan 26 15:45:37 2021* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{8F3C6DA9-A5A1-4E98-9B55-4F0ED711C5FE}\ifc* Database version: 5507* Database creation date: Tue Jan 26 15:45:37 2021* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Jan 26 15:45:37 2021* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Jan 26 15:45:37 2021* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
COBie - Category: Levels; Name: Level 1

# IfcRailing: Railing:NBS_MobilaneUK_CompFncPnls_NoiStop_Green, Railing:NBS_MobilaneUK_CompFncPnls_NoiStop_Green:7057
In: Level 1
PredefinedType: USERDEFINED; Classification: Pr_25_71_50_21 (Uniclass2015); Material: NBS_Mobilane_Wood, NBS_MobilaneUK_Steel-Galvanized, NBS_MobilaneUK_Steel-GalvanizedWire, NBS_MobilaneUK_Polyethylene_Green, Air
BOS_General - Author: NBS; BIMObjectName: NBS_MobilaneUK_CompositeFencePanels_NoiStop_Green; ManufacturerName: Mobilane; ManufacturerURL: https://mobilane.com/en/; NBSCertification: www.nationalbimlibrary.com/cert/n040xlnb; NBSDescription: Composite fence panels; NBSReference: 45-25-05/302; ProductInformation: https://mobilane.com/en/; Revision: n/a; Uniclass2015Title: Composite fence panels; Uniclass2015Code: Pr_25_71_50_21; Uniclass2015Version: Products v1.19; Version: 1
NBS_Data - DimensionsWidth: < 150 mm; DimensionsHeight: Up to a height of 2700 mm; Frame: Galvanized steel framework; Infill: n/a; SlopeAllowance: n/a; AdditionalRequirements: n/a; Application: Can be used to help reduce noise from areas such as: busy roads, railway tracks, neighbouring plots and children's playgrounds; SoundAbsorption: NoiStop® Colour, Steel and Green (DLα): 9 dB(A), Class A3, NoiStop® Wood (DLα): 11 dB(A), Class A3; SoundInsulation: NoiStop® Wood, Steel and Green (DLR): 21 dB(A), Class B2; FireResistance: Class A1; DoorsAndCoverPlates: May only be available with specific product variations. Consult manufacturer for information
IFC - IfcExportAs: IfcRailingType; IfcExportType: USERDEFINED
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_71_50_21:Composite fence panels; CodePerformance: n/a; Color: Colour, Green, Wood ot Steel to suit project requirements; Constituents: Green polyethylene meshing and a core of compressed Rockwool®, in-between galvanized steel framework. Slender construction is 1100 mm deep (NoiStop Green), Finished with lattice work of impregnated wood, combined with aluminium strips and a wire meshing of black polyethylene. Slender construction is 1700 mm deep (NoiStop Wood); Description: Noise-reducing acoustic fencing, constructed of modular panels with a pressed rockwool mineral core for the purpose of outdoor noise damping; DurationUnit: year; ExpectedLife: 20–25 years; Features: Significant noise reduction is achieved by the absorption of approximately 50% of the experienced noise, immediate privacy and safety, high insulation, slender construction, can be used as a windbreak, suitable for use with vegetation, e.g. with Green Screen products, easy to install due to lightweight panels, minimal maintenance required, does not emit any dangerous substances, available in various formats and sizes, and easily customizable, manufactured in accordance with BS EN 14388 and life expectancy of 20–25 years; Finish: Lattice work of impregnated wood (NoiStop Wood), Green polyethylene meshing (NoiStop Green); Grade: n/a; Manufacturer: office@mobilane.co.uk; Material: Green polyethylene meshing and a core of compressed Rockwool®, in-between galvanized steel framework (NoiStop Green), Finished with lattice work of impregnated wood, combined with aluminium strips and a wire meshing of black polyethylene (NoiStop Wood); ModelNumber: n/a; ModelReference: NoiStop; Name: CompositeFencePanels_NoiStop_Green_Mobilane; NominalHeight: 2700 mm; NominalLength: 0 mm; NominalWidth: 150 mm; ReplacementCost: n/a; Shape: Modular panels; Size: 1000 x 450 mm- available for all versions, 1000 x 900 mm- available for all versions, 1000 x 1000 mm- for NoiStop® Green only, 2000 x 450 mm- vailable for all versions, 2000 x 900 mm- available for all versions, 2000 x 1000 mm- for NoiStop® Green only, 3000 x 600 mm - for NoiStop® Steel and NoiStop® Green only; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcRailing: Railing:NBS_MobilaneUK_CompFncPnls_NoiStop_Wood, Railing:NBS_MobilaneUK_CompFncPnls_NoiStop_Wood:7295
In: Level 1
PredefinedType: USERDEFINED; Classification: Pr_25_71_50_21 (Uniclass2015); Material: NBS_Mobilane_Wood, NBS_MobilaneUK_NoiStopWoodSlat, NBS_MobilaneUK_Polyethylene_Black, NBS_MobilaneUK_Steel-Galvanized, NBS_MobilaneUK_NoiStopWood, Air
BOS_General - Author: NBS; BIMObjectName: NBS_MobilaneUK_CompositeFencePanels_NoiStop; ManufacturerName: Mobilane; ManufacturerURL: https://mobilane.com/en/; NBSCertification: www.nationalbimlibrary.com/cert/n040xlnb; NBSDescription: Composite fence panels; NBSReference: 45-25-05/302; ProductInformation: https://mobilane.com/en/; Revision: n/a; Uniclass2015Title: Composite fence panels; Uniclass2015Code: Pr_25_71_50_21; Uniclass2015Version: Products v1.19; Version: 1
NBS_Data - DimensionsWidth: < 150 mm; DimensionsHeight: Up to a height of 2700 mm; Frame: Galvanized steel framework; Infill: n/a; SlopeAllowance: n/a; AdditionalRequirements: n/a; Application: Can be used to help reduce noise from areas such as: busy roads, railway tracks, neighbouring plots and children's playgrounds; SoundAbsorption: NoiStop® Colour, Steel and Green (DLα): 9 dB(A), Class A3, NoiStop® Wood (DLα): 11 dB(A), Class A3; SoundInsulation: NoiStop® Wood, Steel and Green (DLR): 21 dB(A), Class B2; FireResistance: Class A1; DoorsAndCoverPlates: May only be available with specific product variations. Consult manufacturer for information
IFC - IfcExportAs: IfcRailingType; IfcExportType: USERDEFINED
COBie - NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_71_50_21:Composite fence panels; CodePerformance: n/a; Color: Colour, Green, Wood ot Steel to suit project requirements; Constituents: Green polyethylene meshing and a core of compressed Rockwool®, in-between galvanized steel framework. Slender construction is 1100 mm deep (NoiStop Green), Finished with lattice work of impregnated wood, combined with aluminium strips and a wire meshing of black polyethylene. Slender construction is 1700 mm deep (NoiStop Wood); Description: Noise-reducing acoustic fencing, constructed of modular panels with a pressed rockwool mineral core for the purpose of outdoor noise damping; DurationUnit: year; ExpectedLife: 20–25 years; Features: Significant noise reduction is achieved by the absorption of approximately 50% of the experienced noise, immediate privacy and safety, high insulation, slender construction, can be used as a windbreak, suitable for use with vegetation, e.g. with Green Screen products, easy to install due to lightweight panels, minimal maintenance required, does not emit any dangerous substances, available in various formats and sizes, and easily customizable, manufactured in accordance with BS EN 14388 and life expectancy of 20–25 years; Finish: Lattice work of impregnated wood (NoiStop Wood), Green polyethylene meshing (NoiStop Green); Grade: n/a; Manufacturer: office@mobilane.co.uk; Material: Green polyethylene meshing and a core of compressed Rockwool®, in-between galvanized steel framework (NoiStop Green), Finished with lattice work of impregnated wood, combined with aluminium strips and a wire meshing of black polyethylene (NoiStop Wood); ModelNumber: n/a; ModelReference: NoiStop; Name: CompositeFencePanels_NoiStop_Wood_Mobilane; NominalHeight: 2700 mm; NominalWidth: 150 mm; ReplacementCost: n/a; Shape: Modular panels; Size: 1000 x 450 mm- available for all versions, 1000 x 900 mm- available for all versions, 1000 x 1000 mm- for NoiStop® Green only, 2000 x 450 mm- vailable for all versions, 2000 x 900 mm- available for all versions, 2000 x 1000 mm- for NoiStop® Green only, 3000 x 600 mm - for NoiStop® Steel and NoiStop® Green only; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
